# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H753ZI ST STM32H753ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H753xx
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Include; ..\FreeRTOS\; ..\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: IAR.hex
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: stm32h753xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.cpp
  group _EWARM
    ./: startup_stm32h753xx.s stm32h753xx_flash.icf
  group CMSIS/Device
    ../CMSIS/Device/: stm32h753xx.h stm32h7xx.h system_stm32h7xx.c system_stm32h7xx.h
  group CMSIS/Include
    ../CMSIS/Include/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group FreeRTOS
    ../FreeRTOS/: FreeRTOSConfig.h port.c portasm.s portmacro.h
  group FreeRTOS/include
    ../FreeRTOS/include/: deprecated_definitions.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group FreeRTOS/src
    ../FreeRTOS/src/: heap_2.c list.c queue.c tasks.c timers.c
  group user
    ../user/: RCC.cpp
